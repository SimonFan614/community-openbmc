FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-refer-to-https-github.com-systemd-systemd-pull-16149.patch \
           "
