FILESEXTRAPATHS_prepend_as9737-32db := "${THISDIR}/files:"

SRC_URI_append_as9737-32db = " \
    file://as9737-32db.cfg \
    "
